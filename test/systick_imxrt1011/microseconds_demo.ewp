# IAR project microseconds_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MIMXRT1011DAE5A
  ICCARM.CCIncludePath2: ..\..\CMSIS\Include; ..\..\src; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: microseconds_demo.srec
  ILINK.IlinkOutputFile: microseconds_demo.out
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1011DAE5A
  ICCARM.CCOptLevel: 3
  group (top)
    ./: fsl_device_registers.h main.c MIMXRT1011.h MIMXRT1011_features.h startup_MIMXRT1011.s system_MIMXRT1011.c system_MIMXRT1011.h
    ../../src/: microseconds.h microseconds_common.c microseconds_cortexm_systick.c
